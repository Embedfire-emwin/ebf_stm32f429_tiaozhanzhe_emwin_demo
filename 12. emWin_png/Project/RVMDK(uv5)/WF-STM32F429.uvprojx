# Keil uVision project WF-STM32F429.uvprojx, settings and files
target STM32F429 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WF-STM32F429
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\emWin\inc;..\..\emWin\Config;..\..\FATFS;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\emWin\PNG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: main.c stm32f4xx_it.c speedtest.c fatfsDLG.c drawpng.c
  group BSP
    ../../USER/Bsp/led/: bsp_led.c
    ../../USER/Bsp/systick/: bsp_SysTick.c
    ../../USER/Bsp/usart/: bsp_debug_usart.c
    ../../USER/Bsp/beep/: bsp_beep.c
    ../../USER/Bsp/TouchPad/: bsp_touchpad.c
    ../../USER/Bsp/key/: bsp_key.c
    ../../USER/Bsp/lcd/: bsp_lcd.c
    ../../USER/Bsp/sdram/: bsp_sdram.c
    ../../USER/Bsp/font/: fonts.c
    ../../USER/Bsp/touch/: bsp_i2c_touch.c gt9xx.c
    ../../USER/Bsp/usb/: usb_bsp.c usbh_usr.c
  group emWin
    ../../emWin/Config/: GUIConf.c GUIDRV_wf.c
    ../../emWin/OS/: GUI_X.c
    ../../emWin/Lib/: STemWin526_CM4_Keil.lib
  group FatFS
    ../../FATFS/: diskio.c ff.c
    ../../FATFS/drivers/: fatfs_flash_spi.c fatfs_sd_sdio.c fatfs_usb.c
    ../../FATFS/option/: cc936.c
  group USB_HOST
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group png
    ../../emWin/PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
software components: CMSIS:CORE 4.2.0
