# Keil uVision project WF-STM32F429.uvprojx, settings and files
target STM32F429 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WF-STM32F429 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\uCOS_III\uC-CPU;..\..\uCOS_III\uC-LIB;..\..\uCOS_III\uCOS-III\Ports;..\..\uCOS_III\uCOS-III\Source;..\..\USER\os_cfg;..\..\emWin\Config;..\..\emWin\inc;..\..\FATFS;..\..\USER\APP;..\..\USER\Bsp\mpu6050\driver\include;..\..\USER\Bsp\mpu6050\driver\eMPL;..\..\USER\Bsp\mpu6050\driver\stm32L;..\..\USER\Bsp\mpu6050\eMPL-hal;..\..\USER\Bsp\mpu6050\mllite;..\..\USER\Bsp\mpu6050\mpl;..\..\lwip-1.4.1\src\include\ipv4;..\..\lwip-1.4.1\src\include\lwip;..\..\lwip-1.4.1\src\include\netif;..\..\lwip-1.4.1\src\include;..\..\lwip-1.4.1\port;..\..\USER\Bsp\LAN8742A;..\..\lwip-1.4.1\port\arch;..\..\lwip-1.4.1\port\Standalone;..\..\USER\lwipapp;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\USER\USB_App;..\..\USER\mp3\pub;..\..\USER\mp3\real;..\..\USER\Bsp\sdram
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: main.c stm32f4xx_it.c
  group BSP
    ../../USER/Bsp/: bsp.c bsp.h cpu_bsp.c
    ../../USER/Bsp/led/: bsp_led.c
    ../../USER/Bsp/usart/: bsp_debug_usart.c
    ../../USER/Bsp/beep/: bsp_beep.c
    ../../USER/Bsp/TouchPad/: bsp_touchpad.c
    ../../USER/Bsp/key/: bsp_key.c
    ../../USER/Bsp/lcd/: bsp_lcd.c
    ../../USER/Bsp/sdram/: bsp_sdram.c
    ../../USER/Bsp/touch/: bsp_i2c_touch.c gt9xx.c
    ../../USER/Bsp/wm8978/: bsp_wm8978.c
    ../../USER/Bsp/humiture/: humiture.c
    ../../USER/Bsp/sersor_i2c/: sersor_i2c.c
    ../../USER/Bsp/exti/: bsp_exti.c
    ../../USER/Bsp/RTC/: bsp_rtc.c
    ../../USER/Bsp/LAN8742A/: LAN8742A.c stm32f429_eth.c
    ../../USER/Bsp/ov2640/: bsp_ov2640.c
    ../../USER/Bsp/sim900a/: bsp_sim900a.c bsp_usart_gsm.c
    ../../USER/Bsp/adc/: bsp_adc.c
    ../../USER/Bsp/ov5640/: bsp_ov5640.c ov5640_AF.c
  group uCOSIII_CPU
    ../../uCOS_III/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCOSIII_LIB
    ../../uCOS_III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOSIII_Source
    ../../uCOS_III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOSIII_Port
    ../../uCOS_III/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group os_cfg
    ../../USER/os_cfg/: os_app_hooks.c os_app_hooks.h app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h includes.h
  group emWin
    ../../emWin/Lib/: STemWin528_CM4_OS_Keil.lib
    ../../emWin/Config/: GUIConf.c GUIDRV_wf.c
    ../../emWin/OS/: GUI_X_uCOS.c
  group FatFS
    ../../FATFS/: diskio.c ff.c firecc936.c
    ../../FATFS/option/: cc936.c
    ../../FATFS/drivers/: fatfs_flash_spi.c fatfs_sd_sdio.c fatfs_usb.c
  group APP
    ../../USER/APP/: app.c app.h appicon.c rgbledDLG.c pysearch.c keypadapp.c musicDLG.c common.c RecorderDLG.c WeatherDLG.c CompassDLG.c ClockDLG.c NetworkDLG.c CameraDLG.c PhoneDLG.c MessageDLG.c PictureDLG.c USBDLG.c CalculatorDLG.c
    ../../USER/lwipapp/: netconf.c tcp_echoclient.c tcp_echoserver.c udp_echoclient.c
  group MPU_eMPL
    ../../USER/Bsp/mpu6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../USER/Bsp/mpu6050/driver/stm32L/: log_stm32.c
    ../../USER/Bsp/mpu6050/eMPL-hal/: eMPL_outputs.c
    ../../USER/Bsp/mpu6050/: mpu6050.c
  group MPU_mllite
    ../../USER/Bsp/mpu6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../../USER/Bsp/mpu6050/mpl/libmpllib_Keil_M4FP/: libmpllib.lib
  group lwip
    ../../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../lwip-1.4.1/src/netif/: etharp.c
    ../../lwip-1.4.1/port/Standalone/: ethernetif.c
  group USB Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_App
    ../../USER/USB_App/: usb_bsp.c usbd_storage_msd.c usbd_usr.c usbd_desc.c
  group MP3
    ../../USER/mp3/: mp3dec.c mp3tabs.c
    ../../USER/mp3/real/arm/: asmmisc.s asmpoly_thumb2.s
    ../../USER/mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
software components: CMSIS:CORE 4.2.0
